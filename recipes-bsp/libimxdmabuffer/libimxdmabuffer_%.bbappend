SRCBRANCH = "master"
SRCREV = "8be24a6fea38712967758b58327e72a86aab320a"
SRC_URI = "git://github.com/VishvamCorp/libimxdmabuffer;branch=${SRCBRANCH};protocol=https \
           file://run-ptest \
          "